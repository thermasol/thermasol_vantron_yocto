GSTREAMER1p0_PLUGINS_GOOD_1p22_ARAGO = "gstreamer1.0-plugins-good_1.22-arago.inc"

require ${GSTREAMER1p0_PLUGINS_GOOD_1p22_ARAGO}
