
EXTRA_OECONF += " --disable-command-timing"