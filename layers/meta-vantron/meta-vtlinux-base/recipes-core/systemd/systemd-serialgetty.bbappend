# Copyright (C) 2021,Vantron - All Rights Reserved

FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
